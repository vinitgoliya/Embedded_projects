# Keil uVision project togle_switch_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: togle_switch_led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Source Group 1
    ./: STARTUP.A51
    ../app/: main.c
