# Keil uVision project task_creation.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project_lcd_led
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: E:\installed\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Demo\Common\include;E:\installed\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;E:\installed\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\include;..\project_lcd_led;.\include
  asm include: E:\installed\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    E:/installed/Keil_v5/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/: list.c queue.c tasks.c
    E:/installed/Keil_v5/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/portable/MemMang/: heap_2.c
    E:/installed/Keil_v5/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    ./include/: pll0.c uart0.c
    ./src/: lcd.c delay.c
